Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2025-02-09T20:10:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Feb 09 20:10:12 2025 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\87b7a7f5-cc0e-44b0-afdf-3ac90fc7b4a0\e67fa4bc-8766-42d4-bf5e-e2da3d62fc34\ifc * Database version: 5507 * Database creation date: Sun Feb 09 20:10:11 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Feb 09 20:10:11 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Feb 09 20:10:11 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: DB5501.E, DB5501.E:DB5501.E:365322
In: Level 1
Type - PredefinedType: CISTERN
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_89 WC cisterns_Pr_40_20_93_62 Pre-plumbed installation frames; CAWS: N13/66 Pre-plumbed frame system_N13/500 Pre-plumbed frame system_N13/10 WC pans and flushing arrangements_N13/300 WCs and cisterns; CodePerformance: WRAS; Color: White; Constituents: n/a; Description: DolphinBlueElectronicCistern1150Frame; DurationUnit: year; ExpectedLife: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: CISTERN; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; Material: Polyporpylene-Cistern_PowderCoatedSteel-Frame; ModelNumber: DB5501.E; ModelReference: DolphinSolutionsLimited_DolphinBlueElectronicCistern1150Frame; Name: DolphinBlueElectronicCistern1150Frame_DB5501.E; NBSCode: 45-35-70/383 WC cisterns_45-35-70/421 Preplumbed installation frames; NBSDescription: WC Cisterns_Pre-plumbed installation frames; NominalHeight: 1150-1350; NominalLength: 90-145; NominalWidth: 500; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Shape: Rectangle; Size: 1150x90x500; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5501.E; Uniclass2015Code: Pr_40_20_93_89 _Pr_40_20_93_62; Uniclass2015Title: WC Cisterns_Pre-plumbed installation frames; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5501.E
Type - Pset_SanitaryTerminalTypeBath - NominalWidth: 152400 mm; Color: White
Type - Pset_SanitaryTerminalTypeBidet - NominalWidth: 152400 mm; Color: White
Type - Pset_SanitaryTerminalTypeSanitaryFountain - NominalWidth: 152400 mm; Color: White
Type - Pset_SanitaryTerminalTypeShower - NominalWidth: 152400 mm; Color: White
Type - Pset_SanitaryTerminalTypeSink - NominalWidth: 152400 mm; Color: White
Type - Pset_SanitaryTerminalTypeToiletPan - NominalWidth: 152400 mm
Type - Pset_SanitaryTerminalTypeUrinal - NominalWidth: 152400 mm
Type - Pset_SanitaryTerminalTypeWashHandBasin - NominalWidth: 152400 mm; Color: White
Pset_DistributionFlowElementCommon - Reference: DB5501.E; sets with these values: 2
Pset_ElementShading - Color: White
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DolphinBlueElectronicCistern1150Frame; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: DolphinBlueElectronicCistern1150Frame_DB5501.E; Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.882584 m2; Height Extention: 0 mm; Volume: 0.0260047 m3; Wall Thickness: 100 mm
Identity Data - Mark: 1
Other - Family: DB5501.E: DB5501.E; Family and Type: DB5501.E: DB5501.E; Type: DB5501.E: DB5501.E; Type Id: DB5501.E: DB5501.E
Phasing - Phase Created: New Construction
